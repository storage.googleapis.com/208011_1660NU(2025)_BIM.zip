Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e894146a-4833-4a84-92aa-b003607abd5d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 1660NU(2025).ifc
Time: 2025-05-20T22:44:32
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_344289_1
InPort_344289_3

# IfcFlowController: 1660NU(2025):1660NU Shower faucet, 1660NU(2025):1660NU Shower faucet:344289
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 1660NU(2025); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 817; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822); URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1660NU; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1660NU
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Backflow Prevention EN1717: EB; Connection: Eccentric coupling(s); Connection Size: G3/4; Flow Rate At 300kPa: 0.21 dm3/s; Installation Type: Wall mounted; Installation Width: 150 ± 15 mm; Lever Handle: Hot/Cold symbols;Single operating lever/handle; Max. Hot Water Supply: 80 C; Mechanical Parts: ø 35 mm ceramic cartridge for flow and temperature control; Surface treatment: Chrome; Temperature: THERMO COOL; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - NominalDepth: 131.397 mm; NominalHeight: 124.066 mm; NominalWidth: 219 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/1660NU; Catalog Drawing URL: http://static.oras.com/catdrw/1660NU; Category B2C: Shower solutions; Dimension Drawing URL: http://static.oras.com/dimdrw/1660NU; FDV Document URL: http://www.oras.com/datasheet/1660NU/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1660NU; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1660NU; Interactive AR View URL: https://static.oras.com/AR/1660NU; Long Marketing: Introducing this Oras Linea shower faucet - a timeless choice for every modern bathroom. Featuring a sleek chrome finish and wall-mounted installation type, this faucet not only comes with a universal design but also offers outstanding price-performance ratio. It is designed with a single-lever handle and hot and cold symbols for intuitive operation. Choose the Linea line for daily enjoyment in everyday use.; Manufacturer: Oras; Market: International;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1660NU; Model: 1660NU Shower faucet; Name_en: 1660NU Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1660NU; Product Family: Oras Linea; Product Image URL: http://static.oras.com/image/1660NU; Product URL: http://static.oras.com/1660NU; Spare-Part Information URL: http://static.oras.com/sp/1660NU; Technical DataSheet URL: http://www.oras.com/datasheet/1660NU/en; Type Name: 1660NU Shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1660NU(2025); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1660NU; Name: 1660NU Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 220x130x125 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Material: <Unnamed>, Brass
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level 0; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.0758442 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0035998 m3
Identity Data - Mark: 11
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1660NU(2025); Family and Type: 1660NU(2025): 1660NU Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1660NU Shower faucet; Type Id: 344273; WarrantyStartDate: n/a
